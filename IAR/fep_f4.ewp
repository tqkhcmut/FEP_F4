# IAR project fep_f4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ; ..\FreeRTOS\include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\CM4\Device\ST\STM32F4xx\Include; ..\; ..\FreeRTOS\portable\IAR\ARM_CM4F; ..\Utilities\lwip\src\include; ..\Utilities\lwip-contrib\ports\FreeRTOS; ..\Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: fep_f4.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: FreeRTOSConfig.h lwipopts.h main.c main.h stm32f4xx_conf.h
  group Drivers
    ../Drivers/: driver_conf.h drivers.c drivers.h stm32xxx_it.c stm32xxx_it.h
  group Drivers/Buzzer
    ../Drivers/Buzzer/: buzzer.c buzzer.h
  group Drivers/Ethernet
    ../Drivers/Ethernet/: stm32_eth.c stm32_eth.h stm32_eth_bsp.c stm32_eth_bsp.h stm32_eth_conf.h
  group Drivers/FEP
    ../Drivers/FEP/: fep_define.h fep_gpio.c fep_gpio.h fep_list.c fep_list.h fep_process.c fep_process.h fep_rs485.c fep_rs485_getvalue.c fep_udp.c rs485.c rs485.h
  group Drivers/RTC
    ../Drivers/Time/: hal_rtc.c hal_rtc.h
  group Drivers/Serial Debug
    ../Drivers/Serial_Debug/: Retarget.c Serial_Debug.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group StdLib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../Libraries/CMSIS/CM4/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    ../Libraries/CMSIS/CM4/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Tasks
    ../Tasks/: LED_Run_Task.c LED_Run_Task.h
  group Utilities/LwIP
    ../Utilities/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../Utilities/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../Utilities/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Utilities/lwip/src/netif/: etharp.c slipif.c
  group Utilities/LwIP/Port
    ../Utilities/lwip-contrib/ports/FreeRTOS/: ethernetif.c ethernetif.h sys_arch.c sys_arch.h
    ../Drivers/Ethernet/: netconf.c netconf.h
