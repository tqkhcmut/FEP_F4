# Keil uVision project FEP_F4.uvprojx, settings and files
target FEP F4 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FEP_F4 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx HSE_VALUE=8000000
  c include: ..\..\FEP_F4;..\Drivers;..\FreeRTOS\include;..\Utilities\lwip\src\include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM4\Device\ST\STM32F4xx\Include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Utilities\lwip-contrib\ports\FreeRTOS;..\Libraries\CMSIS\CM4\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers
    ../Drivers/Buzzer/: buzzer.c
    ../Drivers/Ethernet/: netconf.c stm32_eth.c stm32_eth_bsp.c
    ../Drivers/Serial_Debug/: Retarget.c Serial_Debug.c
    ../Drivers/Time/: hal_rtc.c
    ../Drivers/: drivers.c stm32xxx_it.c
    ../Drivers/FEP/: fep_gpio.c fep_list.c fep_process.c fep_rs485.c fep_rs485_getvalue.c fep_udp.c rs485.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group StdLib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../Libraries/CMSIS/CM4/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/CM4/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Tasks
    ../Tasks/: LED_Run_Task.c
    ../: main.c
  group Utilities
    ../Utilities/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../Utilities/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Utilities/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../Utilities/lwip/src/netif/: etharp.c slipif.c
    ../Utilities/lwip-contrib/ports/FreeRTOS/: ethernetif.c sys_arch.c
